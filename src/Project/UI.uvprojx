# Keil uVision project UI.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pull_test +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --C99
  c include: ..\User\EPD;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\Fonts;..\User\fliter;..\User\PWM;..\User\rev;..\User\temperature;..\User\HX711;..\User\dispatcher;..\User\UI;..\User\fliter;..\User\OLED;..\User\ADC;..\User\usart;..\User\flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Fonts
    ../User/Fonts/: fontCN.c font32.c font64.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group usart
    ../User/usart/: USART_CONFIG.C
  group Dispatcher
    ../User/dispatcher/: dispatcher.c
  group UI
    ../User/UI/: UI.C
  group FLASH
    ../User/flash/: flash.c
  group ADC
    ../User/ADC/: ADC.C
  group fliter
    ../User/fliter/: fliter.c
  group PWM
    ../User/PWM/: PWM.C
  group HX711
    ../User/HX711/: HX711.C
  group temperature
    ../User/temperature/: temperature.c
  group rev
    ../User/rev/: rev.c
  group OLED
    ../User/OLED/: oled.c
  group DOC
    ../Doc/: readme.txt
